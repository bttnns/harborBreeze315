options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6*4
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1018e3
    low_cutoff_freq: 1000e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/f1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '7'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 314e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 315e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
